# Keil uVision project blinky.uvproj, settings and files
target Blinky @ 0x0000 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: blinky +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Docs
    ./: Abstract.txt
  group Startup
    ./: startup_LPC17xx.s
  group Source
    ./: core_cm3.c system_LPC17xx.c
  group App
    ./: Blinky.c
target Blinky @ 0x2000 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: blinky +hex
  AfterMake: fromelf --bin ".\Flash 0x2000\blinky.axf" --output ".\Flash 0x2000\blinky.bin"
  c flags: Optim=1
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
