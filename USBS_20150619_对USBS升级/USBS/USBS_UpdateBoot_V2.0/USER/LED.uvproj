# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: QiFreeUpdate +hex
  AfterMake: fromelf --bin "..\obj\QiFreeUpdate.axf" --output "..\obj\QiFreeUpdate.bin"
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\dfu;..\QiFree
  memory RVCT4: ROM 0x800a000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c
    ../dfu/: QiFreeMain.c
  group CORE
    ../CORE/: core_cm3.c
    ../QiFree/: startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c
  group dfu
    ../dfu/: flash_if.c stmflash.c usart.c
  group QiFree
    ../QiFree/: QiFreeIO.c
